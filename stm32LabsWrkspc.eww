<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MyLab3\iarproject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MyLab4\iarproject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MyLab1\Lab1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MyLab2\Lab2.ewp</path>
    </project>
    <batchBuild />
</workspace>
