# IAR project lab7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: AHardware; AHardware\Registers; AHardware\Registers\STM32F411; AHardware\Registers\STM32F411\FieldValues; Common; AHardware\Atomic; AHardware\Port; Led; AController; AHardware\InterruptHandler; Temperature; Voltage; Adc; Observer; Solver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: lab7.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp startup.cpp
  group Adc
    Adc/: Adc.cpp Adc.hpp
  group AHardware/Atomic
    AHardware/Atomic/: atomicutils.hpp
  group AHardware/InterruptHandler
    AHardware/InterruptHandler/: interrupthandler.cpp interrupthandler.hpp
  group AHardware/Port
    AHardware/Port/: port.h portsconfig.h
  group AHardware/Registers
    AHardware/Registers/: accessmode.hpp fieldvalue.hpp fieldvaluebase.hpp register.hpp registerbase.hpp registerfield.hpp registertype.hpp
  group AHardware/Registers/STM32F411
    AHardware/Registers/STM32F411/: adc1registers.hpp adccommonregisters.hpp crcregisters.hpp dbgregisters.hpp dma1registers.hpp dma2registers.hpp extiregisters.hpp flashregisters.hpp fpucpacrregisters.hpp fpuregisters.hpp gpioaregisters.hpp gpiobregisters.hpp gpiocregisters.hpp gpiodregisters.hpp gpioeregisters.hpp gpiohregisters.hpp i2c1registers.hpp i2c2registers.hpp i2c3registers.hpp i2s2extregisters.hpp i2s3extregisters.hpp iwdgregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp otgfsdeviceregisters.hpp otgfsglobalregisters.hpp otgfshostregisters.hpp otgfspwrclkregisters.hpp portslist.hpp pwrregisters.hpp rccregisters.hpp rtcregisters.hpp scbactrlregisters.hpp scbregisters.hpp sdioregisters.hpp spi1registers.hpp spi2registers.hpp spi3registers.hpp spi4registers.hpp spi5registers.hpp stkregisters.hpp syscfgregisters.hpp tim10registers.hpp tim11registers.hpp tim1registers.hpp tim2registers.hpp tim3registers.hpp tim4registers.hpp tim5registers.hpp tim8registers.hpp tim9registers.hpp usart1registers.hpp usart2registers.hpp usart6registers.hpp wwdgregisters.hpp
  group AHardware/Registers/STM32F411/FieldValues
    AHardware/Registers/STM32F411/FieldValues/: adc1fieldvalues.hpp adccommonfieldvalues.hpp crcfieldvalues.hpp dbgfieldvalues.hpp dma1fieldvalues.hpp dma2fieldvalues.hpp extifieldvalues.hpp flashfieldvalues.hpp fpucpacrfieldvalues.hpp fpufieldvalues.hpp gpioafieldvalues.hpp gpiobfieldvalues.hpp gpiocfieldvalues.hpp gpiodfieldvalues.hpp gpioefieldvalues.hpp gpiohfieldvalues.hpp i2c1fieldvalues.hpp i2c2fieldvalues.hpp i2c3fieldvalues.hpp i2s2extfieldvalues.hpp i2s3extfieldvalues.hpp iwdgfieldvalues.hpp mpufieldvalues.hpp nvicfieldvalues.hpp nvicstirfieldvalues.hpp otgfsdevicefieldvalues.hpp otgfsglobalfieldvalues.hpp otgfshostfieldvalues.hpp otgfspwrclkfieldvalues.hpp pwrfieldvalues.hpp rccfieldvalues.hpp rtcfieldvalues.hpp scbactrlfieldvalues.hpp scbfieldvalues.hpp sdiofieldvalues.hpp spi1fieldvalues.hpp spi2fieldvalues.hpp spi3fieldvalues.hpp spi4fieldvalues.hpp spi5fieldvalues.hpp stkfieldvalues.hpp syscfgfieldvalues.hpp tim10fieldvalues.hpp tim11fieldvalues.hpp tim1fieldvalues.hpp tim2fieldvalues.hpp tim3fieldvalues.hpp tim4fieldvalues.hpp tim5fieldvalues.hpp tim8fieldvalues.hpp tim9fieldvalues.hpp usart1fieldvalues.hpp usart2fieldvalues.hpp usart6fieldvalues.hpp wwdgfieldvalues.hpp
  group Common
    Common/: susudefs.hpp utils.hpp
  group Led
    Led/: Led.cpp Led.hpp LedsController.cpp LedsController.hpp
  group Observer
    Observer/: Observers.hpp
  group Solver
    Solver/: Solver.cpp Solver.hpp
  group Temperature
    Temperature/: Temperature.cpp Temperature.hpp
  group Voltage
    Voltage/: Voltage.cpp Voltage.hpp
